# Keil uVision project Tetris.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MDR1986BE91 Milandr
  pack: Keil.MDR1986BExx.2.0.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Tetris
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c lcd.h font.h primitives.h figures.h buttons.h cpu.h timers.h pictures.h
software components: CMSIS:CORE 5.0.1, Device:Startup 2.0.3, Drivers:ADC 2.0.3, Drivers:BKP 2.0.3, Drivers:CAN 2.0.3, Drivers:COMP 2.0.3, Drivers:DAC 2.0.3, Drivers:DMA 2.0.3, Drivers:EBC 2.0.3, Drivers:EEPROM 2.0.3, Drivers:I2C 2.0.3, Drivers:IWDG 2.0.3, Drivers:PORT 2.0.3, Drivers:POWER 2.0.3, Drivers:RST_CLK 2.0.3, Drivers:SSP 2.0.3, Drivers:TIMER 2.0.3, Drivers:UART 2.0.3
